# Keil uVision project MODEL.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MODEL +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\CORE;..\Mydriver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c
    ../Mydriver/src/: stm32f10x_PWM.c motor.c SysTickDelay.c DigitalPID.c Servo.c Timer.c HCSR04.c calculate.c HB12864M2A.c stm32f10x_scom.c stm32f10x_scom_it.c stm32f10x_MapSCOMandSBUS.c
    ../Mydriver/inc/: HB.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s stm32f10x_it.c system_stm32f10x.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_rcc.c stm32f10x_flash.c
    ../STM32F10X_FWLib/src/: stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c
